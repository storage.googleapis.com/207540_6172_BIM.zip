Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-24T22:59:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 24 22:59:40 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{B8612B77-D285-4838-B385-6E8127A562DD}\ifc * Database version: 5507 * Database creation date: Fri Aug 24 22:59:39 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 24 22:59:39 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 24 22:59:39 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6172 Washbasin faucet, 6 V, 6172:6172 Washbasin faucet, 6 V:374727
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 172 mm; NominalHeight: 120 mm; NominalWidth: 222 mm; Projection: 100 mm
Type - Electrical(Type) - Battery: Lithium 2CR5 6 V; Operating Voltage: 6 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6172; ConvergoRefNr: 0087-1809-0128-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 24/07/2018
Type - Green Building Properties(Type) - EAN Number: 6414150060410; EMC Directive: 89/336/EEC; EN Standard: EN 15091; ETA-Danmark: VA 1.42/19635; LVI Number: 6117261; Noise Class: I (ISO 3822); NRF Number: 4200022; Protection Class: IP 55; RSK Number: 8553400; VVS Number: 704284304
Type - Identity Data(Type) - Class: Battery-operated, touchless; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;LTU;EST;LVA;RUS;UKR;POL; Model: 6172 Washbasin faucet, 6 V; Name_en: 6172 Washbasin faucet, 6 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6172; Product Datasheet: https://www.oras.com/datasheet/6172/en; Product Family: Oras Electra; Product URL: https://www.oras.com/en/products/oras/product/6172; Type Name: 6172 Washbasin faucet, 6 V; Usage Group: Offices, personnel sanitary facilities;Pharmacies, Opticians, Dentists
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (with magnetic key); Connection Size: G3/4; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/110208_PDM_945443_7_(945443-06-14).pdf; Installation Type: Wall-mounted; Installation Width: CC 150± 3 mm; Intelligent After Flow Period: 3 s ± 2 s; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mechanical Parts: Litter filter(s); Opening Range: 0 - 5 cm; Pressure Loss With Flow 01ls: 200000 Pa; Recognition Range: 40 cm (40 / 50 cm); Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP6179/; Spout Type: Swivel spout; Temperature: Temperature limiter
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6172; Features: Battery-operated, touchless; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6172; Name: 6172 Washbasin faucet, 6 V; ReplacementCost: n/a; Shape: Sculptured; Size: 220x170x120 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Health Sales Arguments: Touch-free operation. Maximum comfort, maximum hygiene.
Pset_ManufacturerTypeInformation - ModelReference: 6172; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6172 Washbasin faucet, 6 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0874667 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00459445 m3
Identity Data - Mark: 29
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6172: 6172 Washbasin faucet, 6 V; Family and Type: 6172: 6172 Washbasin faucet, 6 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6172: 6172 Washbasin faucet, 6 V; Type Id: 6172: 6172 Washbasin faucet, 6 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
